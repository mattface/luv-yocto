RDEPENDS_${PN}_append_class-native_x86 = " ovmf"
RDEPENDS_${PN}_append_class-native_x86-64 = " ovmf"
